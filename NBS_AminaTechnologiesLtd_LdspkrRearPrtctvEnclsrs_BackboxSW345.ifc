Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-08-25T09:37:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Aug 25 09:37:49 2020* Host: NCL-PI04* Database: C:\Users\BocianP\AppData\Local\Temp\{40220BA9-440D-4E78-AB71-A58760BE3009}\ifc* Database version: 5507* Database creation date: Tue Aug 25 09:37:36 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Aug 25 09:37:49 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Aug 25 09:37:49 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: BackboxSW345, NBS_AminaTechnologiesLtd_LdspkrRearPrtctvEnclsrs_BackboxSW345:BackboxSW345:324040
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: Pr_80_77_28_48 (Uniclass2015); Material: NBS_AminaTechnologiesLtd_StainlessSteel
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AminaTechnologiesLtd_LoudspeakerRearProtectiveEnclosures_BackboxSW345; ManufacturerName: Amina Technologies Ltd; ManufacturerURL: https:/​/​uk.aminasound.com/​; NBSCertification: www.nationalbimlibrary.com/cert/smdzmgwe; NBSDescription: Loudspeaker rear protective enclosures; NBSReference: 90-70-10/445; ProductInformation: https://uk.aminasound.com/file-directory/product/accessories/backboxes/datasheet/BackboxSW345_Datasheet.pdf; Revision: n/a; Uniclass2015Title: Loudspeaker rear protective enclosures; Uniclass2015Code: Pr_80_77_28_48; Uniclass2015Version: Products v1.18; Version: 1
Type - NBS_Data - Weight: 2.8 kg; Dimensions: 464 x 359 x 55 mm; SmokeAndFireHoods: n/a; CavityDepth: 60 mm (approximate); Mounting: Solid wall backboxes provide a straightforward and consistent mounting platform for Amina invisible loudspeakers being installed into masonry walls, installed early on in the build process, it requires an accurate cavity to be created in the solid wall or ceiling, large enough to house the backbox and achieve correct alignment; RequiredCavityCutout: 468 x 363 mm; SpeakerCableEntry: Rubber grommets; SpeakerFixing: Four self tapping flange-head screws (supplied); WallFixing: Four screws/ anchors/ wall plugs suitable for the wall/ ceiling structure (not supplied)
Type - Pset_BuildingElementProxyCommon - IsExternal: no; LoadBearing: no; ThermalTransmittance: 0; FireRating: n/a; Reference: n/a
Type - IFC - IfcExportAs: IfcBuildingElementProxyType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_80_77_28_48:Loudspeaker rear protective enclosures; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Solid wall backbox which is an easy to install mounting option into solid or block walls/ ceilings for 345 x 450 mm Amina Invisible Loudspeakers (Edge5i, Edge7i, Mobius5i, Mobius7i, MobiusDual); DurationUnit: year; ExpectedLife: n/a; Features: Rugged, stainless steel mounting option, incorporating resonance damping, rubber alignment trim and cable entry grommets; Finish: n/a; Grade: n/a; Manufacturer: sales@aminasound.com; Material: Stainless steel; ModelNumber: SW345; ModelReference: Backbox SW345; Name: LoudspeakerRearProtectiveEnclosures_BackboxSW345_AminaTechnologiesLtd; NominalHeight: 464 mm; NominalLength: 359 mm; NominalWidth: 55 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 464 x 359 x 55 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: Amina Technologies Ltd
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
